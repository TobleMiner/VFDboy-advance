# Repository TobleMiner/VFDboy-advance

## KiCad design VFDboy.kicad_pcb

Parts:
C1, C2: 20pF; C_0402_1005Metric; LCSC C1554
C3, C6, C7, C8, C9, C35: 100nF; C_0402_1005Metric; LCSC C1525
C4, C5: 1uF; C_0402_1005Metric; LCSC C52923
C10: 4.7uF; C_0603_1608Metric; LCSC C19666
C54, C55, C56, C57, C58, C59: 10nF; C_0402_1005Metric; LCSC C15195
D1: GRN; LED_0603_1608Metric; LCSC C72043
D2: YLW; LED_0603_1608Metric; LCSC C72038
D3: LED_RGB_RBAG; LED_RGB_2020; LCSC C108793
H1, H2: DisplayStandoff; MountingHole_2.7mm_M2.5
H3: D-Pad pivot; MountingHole_5.5mm
H4: MountingHole D-Pad right; MountingHole_GBA_DPAD
H5, H7, H8, H9: MountingHole; MountingHole_3.2mm_M3
H6: MountingHole D-Pad bottom left; MountingHole_GBA_DPAD
H10: MountingHole D-Pad top left; MountingHole_GameBoy_DPAD
H11: MountingHole D-Pad bottom right; MountingHole_GameBoy_DPAD
H12: MountingHole AB bottom left; MountingHole_GameBoy_DPAD
H13: MountingHole AB top right; MountingHole_GameBoy_DPAD
H14: MountingHole AB bottom right; MountingHole_GBA_AB_bottom_right
H15: MountingHole AB top left; MountingHole_3.5mm
H16, H17: ToolingHole; ToolingHole_JLCSMT
J1: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
JP1: ~HWB; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
LS1: Speaker; MLT_7525; LCSC C95299
R1, R3, R4, R5, R22: 8.2kR; R_0402_1005Metric; LCSC C25924
R2, R6: 3.3kR; R_0402_1005Metric; LCSC C25890
R21: 0R; R_0402_1005Metric; LCSC C17168
SW1: RIGHT; Button_Carbon_5mm
SW2: A; Button_Carbon_5mm
SW3: DOWN; Button_Carbon_5mm
SW4: UP; Button_Carbon_5mm
SW5: LEFT; Button_Carbon_5mm
SW6: B; Button_Carbon_5mm
SW7: D-Pad; Daughterboard_D-Pad
SW9: AB; Daugtherboard_AB
U1: ATmega32U4-MU; QFN-44-1EP_7x7mm_P0.5mm_EP5.2x5.2mm; LCSC C45874
U2: SSD1306_VFD
U7: SRV05-4; SOT-23-6; LCSC C85364
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C13738

Connections:
+5V: C6.2, C7.2, C8.1, C9.1, C35.1, D1.2 (A), D2.2 (A), D3.3 (A), J1.2 (VCC), R1.1, U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC), U2.1 (VCC), U7.5 (VP); also elsewhere on the board
/A: C58.2, SW2.1, SW9.1 (A), U1.1 (PE6); also elsewhere on the board
/B: C59.1, SW6.1, SW9.3 (B), U1.28 (PB4); also elsewhere on the board
/D+: U1.4 (D+), U7.3 (IO2); also elsewhere on the board
/D-: U1.3 (D-), U7.1 (IO1); also elsewhere on the board
/DOWN: C54.1, SW3.1, SW7.3 (DOWN), U1.39 (PF4); also elsewhere on the board
/LEFT: C57.1, SW5.1, SW7.4 (LEFT), U1.38 (PF5); also elsewhere on the board
/MISO: J1.1 (MISO), U1.11 (PB3); also elsewhere on the board
/MOSI: J1.4 (MOSI), U1.10 (PB2), U2.8 (MOSI); also elsewhere on the board
/RIGHT: C55.1, SW1.1, SW7.2 (RIGHT), U1.37 (PF6); also elsewhere on the board
/SCK: J1.3 (SCK), U1.9 (PB1), U2.9 (SCK); also elsewhere on the board
/SPKR+: C10.1, R21.2, U7.4 (IO3)
/SPKR-: LS1.2, U1.32 (PC7), U7.6 (IO4)
/UP: C56.1, SW4.2, SW7.5 (UP), U1.36 (PF7); also elsewhere on the board
/~CS: U1.26 (PD6), U2.7 (~CS); also elsewhere on the board
/~DC: U1.25 (PD4), U2.6 (~DC); also elsewhere on the board
/~OLEDRST: R22.1, U1.27 (PD7), U2.5 (~RST); also elsewhere on the board
/~RST: C3.2, J1.5 (~RST), R1.2, U1.13 (~RESET); also elsewhere on the board
unnamed: C1.2, U1.17 (XTAL1), Y1.3
unnamed: C2.1, U1.16 (XTAL2), Y1.1
unnamed: C4.1, U1.6 (UCAP)
unnamed: C10.2, U1.31 (PC6)
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R6.1
unnamed: D3.1 (RK), R2.1
unnamed: D3.2 (BK), R4.1
unnamed: D3.4 (GK), R3.1
unnamed: JP1.1, U1.33 (~HWB~/PE2)
unnamed: LS1.1, R21.1
unnamed: R2.2, U1.29 (PB5)
unnamed: R3.2, U1.30 (PB6)
unnamed: R4.2, U1.12 (PB7)
unnamed: R5.2, U1.8 (PB0)
unnamed: R6.2, U1.22 (PD5)
VBUS: C5.2, U1.2 (UVCC), U1.7 (VBUS); also elsewhere on the board

Parts:
BT1: 6060100; LiPo_6060100
BT2: 606090; LiPo_606090
C11, C12, C14, C15, C31, C32: 47uF; C_1206_3216Metric; LCSC C96123
C13, C16, C17, C28: 1uF; C_0402_1005Metric; LCSC C52923
C18, C27, C29, C30: 100nF; C_0402_1005Metric; LCSC C1525
C19, C26: 10uF; C_0603_1608Metric; LCSC C19702
D4: LED; LED_0603_1608Metric; LCSC C2286
F1, F2: 2A; Fuse_1206_3216Metric; LCSC C182310
J2: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
L1: 2.2uH; YSPI0530; LCSC C351096
Q1: FS8205A; TSSOP-8_4.4x3mm_P0.65mm; LCSC C16052
Q6, Q8: 2N7002; SOT-23; LCSC C8545
Q7: AO3401A; SOT-23; LCSC C15127
R7, R8: 5.1kR; R_0402_1005Metric; LCSC C25905
R9, R10, R29, R35: 1MR; R_0402_1005Metric; LCSC C26083
R11, R23: 300kR; R_0402_1005Metric; LCSC C25774
R12: 1kR; R_0402_1005Metric; LCSC C11702
R13: 470R; R_0402_1005Metric; LCSC C25117
R14: 3.3kR; R_0402_1005Metric; LCSC C25890
R15, R26: 2.2kR; R_0402_1005Metric; LCSC C25879
R27, R36: 8.2kR; R_0402_1005Metric; LCSC C25924
R30, R31: 100R; R_0402_1005Metric; LCSC C25076
R32: 25mR; R_2512_6332Metric; LCSC C87219
TH1: 10kR 3380K; R_0402_1005Metric; LCSC C77131
TP1: BAT+; TestPoint_Pad_4.0x4.0mm
U3: SY7088; DFN-8-1EP_3x2mm_P0.5mm_EP1.3x1.5mm; LCSC C178240
U4: XC6206P332MR; SOT-23; LCSC C5446
U5: DW01+G; SOT-23-6; LCSC C14213
U6: TP4056; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm; LCSC C16581
U9: BQ34Z100; TSSOP-14_4.4x5mm_P0.65mm; LCSC C91302

Connections:
+3V3: C17.2, U4.2 (VO); also elsewhere on the board
+5V: C31.2, C32.2; also elsewhere on the board
+BATT: C11.2, C12.2, C13.1, C16.1, C26.1, C27.2, F2.2, L1.1, R13.2, U3.6 (IN), U4.3 (VI), U6.5 (BAT), U9.4 (BAT), U9.6 (REGIN)
/D+: J2.A6 (D+), J2.B6 (D+); also elsewhere on the board
/D-: J2.A7 (D-), J2.B7 (D-); also elsewhere on the board
/Power/GAUGE_EN: R29.2, U9.5 (CE); also elsewhere on the board
/Power/Ichg: C30.1, R36.1; also elsewhere on the board
/Power/LEDchg: D4.1 (K), R27.1, U6.7 (~CHRG); also elsewhere on the board
/Power/PWR_EN: Q6.1 (G), R9.1, R35.1, U3.3 (EN); also elsewhere on the board
/Power/Power switch/VSTEP_UP: C14.2, C15.2, R10.1, U3.7 (OUT), U3.8 (OUT); also elsewhere on the board
/Power/Power switch/VUSB: Q7.3 (D); also elsewhere on the board
/Power/SCL: U9.13 (P4/SCL); also elsewhere on the board
/Power/SDA: U9.14 (P3/SDA); also elsewhere on the board
/Power/~PWR_EN: Q6.3 (D), Q7.1 (G), Q8.1 (G), R23.2
unnamed: BT1.1 (+), BT2.1 (+), F2.1
unnamed: BT1.2 (-), BT2.2 (-), C18.1, Q1.6, Q1.7, U5.6 (VSS)
unnamed: C18.2, R13.1, U5.5 (VDD)
unnamed: C28.2, TH1.2, U9.7 (REG25)
unnamed 58: C29.1, R30.2, U9.9 (SRP); also elsewhere on the board
unnamed 59: C29.2, R31.1, U9.10 (SRN); also elsewhere on the board
unnamed: D4.2 (A), R14.2
unnamed: F1.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: J2.A5 (CC1), R7.2
unnamed: J2.B5 (CC2), R8.1
unnamed: L1.2, U3.1 (LX), U3.2 (LX)
unnamed: Q1.1, Q1.8
unnamed: Q1.4, U5.3 (CO)
unnamed: Q1.5, U5.1 (DO)
unnamed: Q8.3 (D), R26.2
unnamed: R10.2, R11.1, U3.5 (FB)
unnamed: R12.2, U5.2 (VM)
unnamed: R15.1, R26.1, R36.2, U6.2 (PROG)
unnamed: TH1.1, U9.11 (P6/TS)
VBUS: C19.2, F1.1, Q7.2 (S), R14.1, R23.1, R27.2, U6.4 (VCC), U6.8 (CE); also elsewhere on the board

Notes on the sheet:
+5.2V
Ichg=500mA/1A

Parts:
C20: 10uF; C_0603_1608Metric; LCSC C19702
C21, C22, C23, C24, C25, C60: 100nF; C_0402_1005Metric; LCSC C1525
D5: PWR; LED_0603_1608Metric; LCSC C2290
J3: Micro_SD_Card_Det; HOAUC_HYC77-TF09-200
J4: TagConnect_TC2030_SWD; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
Q9: AO3401A; SOT-23; LCSC C15127
R24: 300kR; R_0402_1005Metric; LCSC C25774
R25, R28: 8.2kR; R_0402_1005Metric; LCSC C25924
R33, R34: 3.3kR; R_0402_1005Metric; LCSC C25890
SW8: POWER; TS-1187A-X-X-X; LCSC C318886
U8: STM32L151C8Tx; LQFP-48_7x7mm_P0.5mm; LCSC C95578

Connections:
+3V3: C22.1, C23.1, C24.2, C25.2, J4.1 (VTGT), Q9.2 (S), R24.1, SW8.2, U8.1 (VLCD), U8.9 (VDDA), U8.24 (VDD), U8.36 (VDD), U8.48 (VDD); also elsewhere on the board
/A: U8.45 (PB8); also elsewhere on the board
/B: U8.46 (PB9); also elsewhere on the board
/DOWN: U8.42 (PB6); also elsewhere on the board
/LEFT: U8.43 (PB7); also elsewhere on the board
/Leds/DIN: U8.33 (PA12); also elsewhere on the board
/MISO: U8.27 (PB14); also elsewhere on the board
/MOSI: U8.28 (PB15); also elsewhere on the board
/Power/GAUGE_EN: R33.2, R34.2, U8.20 (PB2); also elsewhere on the board
/Power/Ichg: U8.13 (PA3); also elsewhere on the board
/Power/LEDchg: U8.11 (PA1); also elsewhere on the board
/Power/PWR_EN: U8.12 (PA2); also elsewhere on the board
/Power/SCL: R34.1, U8.21 (PB10); also elsewhere on the board
/Power/SDA: R33.1, U8.22 (PB11); also elsewhere on the board
/RIGHT: U8.39 (PB3); also elsewhere on the board
/SCK: U8.26 (PB13); also elsewhere on the board
/STM32/LED_PWR: R25.2, U8.3 (PC14)
/STM32/SD_MISO: J3.7 (DAT0), U8.16 (PA6)
/STM32/SD_MOSI: J3.3 (CMD), U8.17 (PA7)
/STM32/SD_PWR: C20.2, J3.4 (VDD), Q9.3 (D)
/STM32/SD_SCK: J3.5 (CLK), U8.15 (PA5)
/STM32/SD_~CS: J3.2 (DAT3/CD), U8.14 (PA4)
/STM32/SD_~DET: J3.10 (DET_A), U8.18 (PB0)
/STM32/~STMRST: C21.2, J4.3 (~RESET), U8.7 (NRST)
/UP: U8.41 (PB5); also elsewhere on the board
/~CS: U8.31 (PA10); also elsewhere on the board
/~DC: U8.38 (PA15); also elsewhere on the board
/~OLEDRST: U8.30 (PA9); also elsewhere on the board
/~RST: U8.29 (PA8); also elsewhere on the board
unnamed: C60.1, SW8.1, U8.10 (PA0)
unnamed: D5.2 (A), R25.1
unnamed: J4.2 (SWDIO), U8.34 (PA13)
unnamed: J4.4 (SWCLK), U8.37 (PA14)
unnamed: Q9.1 (G), R24.2, U8.19 (PB1)
unnamed: R28.1, U8.2 (PC13)
VBUS: R28.2; also elsewhere on the board

Notes on the sheet:
WKUP1
WKUP2
MOSI
MISO
SCK
~CS
~JTRST

Parts:
Q2, Q5: S9015; SOT-23; LCSC C2149
Q3, Q4: AO3401A; SOT-23; LCSC C15127
R16, R17: 33kR; R_0402_1005Metric; LCSC C25779
R18: 1kR; R_0402_1005Metric; LCSC C11702
R19, R20: 100kR; R_0402_1005Metric; LCSC C25741

Connections:
+5V: Q3.2 (S), Q4.2 (S), Q5.2 (E); also elsewhere on the board
/Power/Power switch/VSTEP_UP: Q4.3 (D); also elsewhere on the board
/Power/Power switch/VUSB: Q2.2 (E), Q3.3 (D), R18.2; also elsewhere on the board
unnamed: Q2.1 (B), Q2.3 (C), Q5.1 (B), R16.1
unnamed: Q3.1 (G), Q5.3 (C), R20.1
unnamed: Q4.1 (G), R18.1, R19.1
unnamed: R16.2, R17.1

Parts:
C53: 1uF; C_0402_1005Metric; LCSC C52923
D23: WS2812C-2020; LED_RGB_2020_WS2812C; LCSC C965556

Connections:
+5V: C53.1, D23.1 (VDD); also elsewhere on the board
/Leds/DIN: D23.4 (DIN); also elsewhere on the board
/Leds/Led 2/DIN: D23.2 (DOUT); also elsewhere on the board

Parts of its further copies:
C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49, C50, C51, C52: 1uF; C_0402_1005Metric; LCSC C52923
D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22: WS2812C-2020; LED_RGB_2020_WS2812C; LCSC C965556

Connections of its further copies:
+5V: C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C48.1, C49.1, C50.1, C51.1, C52.1, D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D18.1 (VDD), D19.1 (VDD), D20.1 (VDD), D21.1 (VDD), D22.1 (VDD); also elsewhere on the board
/Leds/Led 2/DIN: D22.4 (DIN); also elsewhere on the board
/Leds/Led 3/DIN: D21.4 (DIN), D22.2 (DOUT)
/Leds/Led 4/DIN: D20.4 (DIN), D21.2 (DOUT)
/Leds/Led 5/DIN: D19.4 (DIN), D20.2 (DOUT)
/Leds/Led 9/DIN: D9.4 (DIN), D19.2 (DOUT)
/Leds/Led 10/DIN: D9.2 (DOUT), D18.4 (DIN)
/Leds/Led 11/DIN: D10.4 (DIN), D18.2 (DOUT)
/Leds/Led 12/DIN: D10.2 (DOUT), D11.4 (DIN)
/Leds/Led 13/DIN: D11.2 (DOUT), D12.4 (DIN)
/Leds/Led 14/DIN: D12.2 (DOUT), D13.4 (DIN)
/Leds/Led 15/DIN: D13.2 (DOUT), D14.4 (DIN)
/Leds/Led 15/DOUT: D14.2 (DOUT)

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
Board: 2 copper layers, 141.2 x 60.0 mm, 163 parts (1 on the bottom side), 97 nets.

Other parts of the board:
C33, C34: 100nF; C_0402_1005Metric

Their connections:
unnamed 58: C33.1; also elsewhere on the board
unnamed 59: C34.2; also elsewhere on the board

## KiCad design button-daughterboard/button-daughterboard.kicad_pcb

Board: 2 copper layers, 88.0 x 65.4 mm, 75 parts (24 on the bottom side), 19 nets.

Parts:
H1, H12, H23: D-Pad Hole; MountingHole_5.5mm
H2, H13, H24: D-Pad top left; MountingHole_GameBoy_DPAD
H3, H14, H25: D-Pad bottom right; MountingHole_GameBoy_DPAD
H4, H5, H6, H7, H10, H11, H15, H16, H17, H18, H21, H22, H26, H27, H28, H29, H32, H33: MountingHole; MountingHole_3.2mm_M3
H8, H19, H30: AB top left; MountingHole_3.5mm
H9, H20, H31: AB bottom right; MountingHole_GBA_AB_bottom_right
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18: SW_Push; Button_Carbon_5mm

Connections:
GND: J5.1, J7.1, J13.1, J16.1, J21.1, J24.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, SW17.2, SW18.2
unnamed: J1.1, SW1.1
unnamed: J2.1, SW2.1
unnamed: J3.1, SW3.1
unnamed: J4.1, SW4.1
unnamed: J6.1, SW5.1
unnamed: J8.1, SW6.1
unnamed: J9.1, SW7.1
unnamed: J10.1, SW8.1
unnamed: J11.1, SW9.1
unnamed: J12.1, SW10.1
unnamed: J14.1, SW11.1
unnamed: J15.1, SW12.1
unnamed: J17.1, SW13.1
unnamed: J18.1, SW14.1
unnamed: J19.1, SW15.1
unnamed: J20.1, SW16.1
unnamed: J22.1, SW17.1
unnamed: J23.1, SW18.1

## Commit log

2021-01-08 Add self-programming capability
2021-01-08 Add charge state/current sensing and VBUS wakeup source
2021-01-08 Add BQ34Z100 fuel gauge symbol
2021-01-08 Implement fuel gauging
2021-01-08 Partially routed
2021-01-08 route VFD power
2021-01-09 Finish layout
2021-01-09 Add additional mounting holes
2021-01-10 Add VFD 3D model
2021-01-10 Add last 3d models
2021-01-10 Hide silkscreen designators
2021-01-10 Mark SMT components as SMT
2021-01-10 Add 6060100 and 606090 LiPo footprints
2021-01-10 Replace test points by battery footprints
2021-01-10 Route SD interface
2021-01-10 Hookup VFD
2021-01-11 Connect buttons
2021-01-11 Route VBUS
2021-01-11 Route charger controls
2021-01-11 route RGB LED
2021-01-16 Add GBA dpad mounting holes
2021-01-16 Add support for GBA D-Pad mounting
2021-01-16 Add Game Boy compatible D-Pad mounting holes
2021-01-16 Add AB button mounting
2021-01-16 Fix rubber mounting mechanicals
    Hole spacings were off by quite a bit
2021-01-16 Add tooling holes
2021-01-16 Add Pin 1 markers
2021-01-16 Add TVS diode pin 1 marker
2021-01-16 Place and route WS2812 LEDs
2021-01-16 Perform via stitching
2021-01-16 Hide all silkscreen reference designators
2021-01-17 Add D-Pad daugtherboard
2021-01-17 Add D-Pad 3d model
2021-01-17 Add D-Pad footprint
2021-01-17 Add option for elevated D-Pad
2021-01-17 Hide silkscreen reference designators
2021-01-18 Add AB buttons
2021-01-18 Implement elevated AB surfaces
2021-01-18 Add some margin left of B button
2021-01-19 Panelize button daughterboards
2021-01-19 Use tactile power switch
2021-01-19 Reduce paste coverage on QFN and DFN thermal pads
2021-01-19 Fix LCSC partnumbers
2021-01-19 Remove large name
    JLCPCB does not support black solder resist + ENIG for assembly
2021-01-19 Add schematic export
